Commit message: move walls origin

File: res/urdf/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=2000 2000 0.001; visual mesh filename=package://laas_objects/res/obj/plane.obj scale=1 1 1
